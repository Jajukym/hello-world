# Keil uVision project Combine_PSoC5lib.uvproj, settings and files
target Debug (ARM-GNU)
  device: CY8C5568AXI-060 Cypress
  cpu: "IRAM(0x1FFF8000-0x20007FFF)IROM(0x0-0x3FFFF)CLOCK(67000000)CPUTYPE( "Cortex-M3") ESEL ELITTLE"
  output: Combine_PSoC5lib (library)
  group Source Files
    ./Generated_Source/PSoC5/: cyfitter_cfg.h cyfitter_cfg.c cydevice.h cydevicegnu.inc cydevicerv.inc cydevice_trm.h cydevicegnu_trm.inc cydevicerv_trm.inc cyfittergnu.inc cyfitterrv.inc cyfitter.h cm3gcc.ld Cm3RealView.scat core_cm3_psoc5.h core_cm3.c core_cm3.h CyBootAsmGnu.s CyDmac.c CyDmac.h CyFlash.c CyFlash.h CyLib.c CyLib.h cypins.h cyPm.c cyPm.h CySpc.c CySpc.h cytypes.h cyutils.c project.h shiftregReceiver.c shiftregReceiver.h shiftregReceiver_PM.c shiftregSender.c shiftregSender.h shiftregSender_PM.c clockShift.c clockShift.h isrLoadInt.c isrLoadInt.h counterShift.c counterShift.h counterShift_PM.c isrStoreInt.c isrStoreInt.h pinCalibrateOut_aliases.h pinCalibrateOut.c pinCalibrateOut.h pinCalibrateIn_aliases.h pinCalibrateIn.c pinCalibrateIn.h pinClock_aliases.h pinClock.c pinClock.h pinShift_Load_aliases.h pinShift_Load.c pinShift_Load.h pinPolarC_aliases.h pinPolarC.c pinPolarC.h pinPolarS_aliases.h pinPolarS.c pinPolarS.h pinPolarCLED_aliases.h pinPolarCLED.c pinPolarCLED.h pinPolarSLED_aliases.h pinPolarSLED.c pinPolarSLED.h pinANTPlus_aliases.h pinANTPlus.c pinANTPlus.h pinANTPlusLED_aliases.h pinANTPlusLED.c pinANTPlusLED.h counterPolarC.c counterPolarC.h counterPolarC_PM.c clockPulseCount.c clockPulseCount.h counterPolarS.c counterPolarS.h counterPolarS_PM.c counterANTPlus.c counterANTPlus.h counterANTPlus_PM.c clockButtonRead.c clockButtonRead.h pinDMK_aliases.h pinDMK.c pinDMK.h pgaPolarC.c pgaPolarC.h pgaPolarC_PM.c pgaPolarS.c pgaPolarS.h pgaPolarS_PM.c pgaANTPlus.c pgaANTPlus.h pgaANTPlus_PM.c statusButton.c statusButton.h pinButton1_aliases.h pinButton1.c pinButton1.h pinButton2_aliases.h pinButton2.c pinButton2.h pinButton3_aliases.h pinButton3.c pinButton3.h pinButton4_aliases.h pinButton4.c pinButton4.h pinButton5_aliases.h pinButton5.c pinButton5.h pinButton6_aliases.h pinButton6.c pinButton6.h pinButton7_aliases.h pinButton7.c pinButton7.h pinButton8_aliases.h pinButton8.c pinButton8.h lcdDisplay.c lcdDisplay.h lcdDisplay_PM.c lcdDisplay_LCDPort_aliases.h lcdDisplay_LCDPort.c lcdDisplay_LCDPort.h PWMPulseCapture.c PWMPulseCapture.h PWMPulseCapture_PM.c isrPulseCapture.c isrPulseCapture.h
target Release (ARM-GNU)
  device: CY8C5568AXI-060 Cypress
  cpu: as above
  output: Combine_PSoC5lib (library)
