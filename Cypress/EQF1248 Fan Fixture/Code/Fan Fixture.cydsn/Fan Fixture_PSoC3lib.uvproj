# Keil uVision project Fan Fixture_PSoC3lib.uvproj, settings and files
target Debug (MCS-51)
  device: CY8C3246LTI-149 Cypress
  cpu: "IRAM(0x00-0xFF) IROM(0x0-0xFFFF) CLOCK(0) MODDP2"
  output: Fan Fixture_PSoC3lib (library)
  c flags: Optimize=2
  c define: DEBUG
  c misc: PR(${OutputDir}\${CompileFile}.lst) CD MODDP2
  c include: .;.\Generated_Source\PSoC3
  asm define: DEBUG
  asm misc: NOCO PR(${OutputDir}/${CompileFile}.lst)
  asm include: .;.\Generated_Source\PSoC3
  link misc: IX CODE RU
  group Source Files
    ./Generated_Source/PSoC3/: cyfitter_cfg.h cyfitter_cfg.c cydevice.h cydevicekeil.inc cydevice_trm.h cydevicekeil_trm.inc cyfitterkeil.inc cyfitter.h pinPWM.c pinPWM.h pinPWM_aliases.h pinUp.c pinUp.h pinUp_aliases.h pinDown.c pinDown.h pinDown_aliases.h pwmFan.c pwmFan.h pwmFan_PM.c clkPWM.c clkPWM.h CyBootAsmKeil.a51 CyDmac.c CyDmac.h CyFlash.c CyFlash.h CyLib.c CyLib.h cymem.a51 cypins.h cyPm.c cyPm.h CySpc.c CySpc.h cytypes.h cyutils.c PSoC3_8051.h PSoC3_8051.inc project.h statusButtons.c statusButtons.h clkDebounce.c clkDebounce.h isrButton.c isrButton.h lcdDisplay.c lcdDisplay.h lcdDisplay_PM.c lcdDisplay_LCDPort.c lcdDisplay_LCDPort.h lcdDisplay_LCDPort_aliases.h pinMode.c pinMode.h pinMode_aliases.h pinStart.c pinStart.h pinStart_aliases.h pwmFan2.c pwmFan2.h pwmFan2_PM.c clkPWM2.c clkPWM2.h isrUpdateDisplay.c isrUpdateDisplay.h clkDisplay.c clkDisplay.h pinPWM2.c pinPWM2.h pinPWM2_aliases.h pinVFan.c pinVFan.h pinVFan_aliases.h adcVFan.c adcVFan.h adcVFan_PM.c adcVFan_INT.c adcVFan_theACLK.c adcVFan_theACLK.h adcVFan_Ext_CP_Clk.c adcVFan_Ext_CP_Clk.h adcVFan_AMux.c adcVFan_AMux.h cydisabledsheets.h adcVFan_IRQ.c adcVFan_IRQ.h cy_em_eeprom.c cy_em_eeprom.h cycodeshareimport.ld cycodeshareexport.ld cycodeshareimport.scat eepromTime.c eepromTime.h rtcClock.c rtcClock.h rtcClock_INT.c
target Release (MCS-51)
  device: CY8C3246LTI-149 Cypress
  cpu: "IRAM(0x00-0xFF) IROM(0x0-0xFFFF) CLOCK(0) MODDP2"
  output: Fan Fixture_PSoC3lib (library)
  c flags: Optimize=8
  c define: NDEBUG
  c misc: PR(${OutputDir}\${CompileFile}.lst) CD MODDP2
  c include: .;.\Generated_Source\PSoC3
  asm define: NDEBUG
  asm misc: NOCO PR(${OutputDir}/${CompileFile}.lst)
  asm include: .;.\Generated_Source\PSoC3
  link misc: IX CODE RU
