# Keil uVision project CE95396_PSoC3lib.uvproj, settings and files
target Debug (MCS-51)
  device: CY8C3866AXI-040 Cypress
  cpu: "IRAM(0x00-0xFF) IROM(0x0-0xFFFF) CLOCK(0) MODDP2"
  output: CE95396_PSoC3lib (library)
  c flags: Optimize=2
  c misc: PR(${OutputDir}/${CompileFile}.lst) CD MODDP2
  c include: .;.\Generated_Source\PSoC3
  asm misc: NOCO PR(${OutputDir}/${CompileFile}.lst) CASE EP
  asm include: .;.\Generated_Source\PSoC3
  link misc: CODE RU RC(10) IX CL(XDATA(X:0x0000-X:0x1FFF)) CL(CODE(C:0x0000-C:0xFFFF)) CL(CONST(C:0x0000-C:0xFFFF))
  group Source Files
    ./Generated_Source/PSoC3/: cyfitter_cfg.h cyfitter_cfg.c cydevice.h cydevicekeil.inc cydevice_trm.h cydevicekeil_trm.inc cyfitterkeil.inc cyfitter.h cydisabledsheets.h USBUART_1.c USBUART_1.h USBUART_1_audio.c USBUART_1_audio.h USBUART_1_boot.c USBUART_1_cdc.c USBUART_1_cdc.h USBUART_1_cls.c USBUART_1_descr.c USBUART_1_drv.c USBUART_1_episr.c USBUART_1_hid.c USBUART_1_hid.h USBUART_1_pm.c USBUART_1_std.c USBUART_1_vnd.c USBUART_1_cdc.inf USBUART_1_midi.c USBUART_1_midi.h USBUART_1_pvt.h USBUART_1_cydmac.h USBUART_1_msc.c USBUART_1_msc.h LCD.c LCD.h LCD_PM.c USBUART_1_Dm.c USBUART_1_Dm.h USBUART_1_Dm_aliases.h USBUART_1_Dp.c USBUART_1_Dp.h USBUART_1_Dp_aliases.h LCD_LCDPort.c LCD_LCDPort.h LCD_LCDPort_aliases.h CyBootAsmKeil.a51 CyDmac.c CyDmac.h CyFlash.c CyFlash.h CyLib.c CyLib.h cymem.a51 cypins.h cyPm.c cyPm.h CySpc.c CySpc.h cytypes.h cyutils.c PSoC3_8051.h PSoC3_8051.inc cy_em_eeprom.c cy_em_eeprom.h project.h cycodeshareimport.ld cycodeshareexport.ld cycodeshareimport.scat
target Release (MCS-51)
  device: CY8C3866AXI-040 Cypress
  cpu: "IRAM(0x00-0xFF) IROM(0x0-0xFFFF) CLOCK(0) MODDP2"
  output: CE95396_PSoC3lib (library)
  c flags: Optimize=5 SizeSpeed=1
  c define: NDEBUG
  c misc: PR(${OutputDir}/${CompileFile}.lst) CD MODDP2
  c include: .;.\Generated_Source\PSoC3
  asm define: NDEBUG
  asm misc: NOCO PR(${OutputDir}/${CompileFile}.lst) CASE EP
  asm include: .;.\Generated_Source\PSoC3
  link misc: as above
